# Keil uVision project USB_HID_IIC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USB_HID_IIC +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Applications\Application_Main
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_adc.c
  group User
    ../User/: main.c stm32f10x_it.c usbio.c UserProgram.c User_IIC.c User_PWM.c User_Exti.c
  group Appliacation_main
    ../Applications/Application_Main/: Application_main.cpp Application_init_device.cpp Chip_AW981x.cpp Chip_AW9163.cpp Application_LED.cpp Application_LED_effect.cpp Application_KEY.cpp Application_LED_interface.cpp Application_LED_customize.cpp Application_KEY_customize.cpp Application_commu_handle.cpp
